# Keil uVision project IBP-D SoftWare.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IBP-D firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c Initialization.c Global_Var.c Global_Var.h Defines.h Configuration.h Interrupts.c Function.c I2C_interface.c stdlib.h RS485_interface.c Save_Flash.c Function_Interrupts.c string.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.2i, Drivers:ADC 2.0.2i, Drivers:COMP 2.0.2i, Drivers:DAC 2.0.2i, Drivers:DMA 2.0.2i, Drivers:EEPROM 2.0.2i, Drivers:I2C 2.0.2i, Drivers:IWDG 2.0.2i, Drivers:PORT 2.0.2i, Drivers:POWER 2.0.2i, Drivers:RST_CLK 2.0.2i, Drivers:SSP 2.0.2i, Drivers:TIMER 2.0.2i, Drivers:UART 2.0.2i, Drivers:WWDG 2.0.2i
